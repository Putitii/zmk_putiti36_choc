## config/boards/shields/putiti36_choc/Kconfig.defconfig
```kconfig
if SHIELD_PUTITI36_choc

config ZMK_KEYBOARD_NAME
	default "putiti36_choc"
endif
```
